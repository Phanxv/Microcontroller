# Keil uVision project STM32L152RB.uvprojx, settings and files
target Demonstrate (6190000::V6.19::ARMCLANG)
  device: STM32L152RB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.4.1
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32L152RB
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32L1xB, USE_FULL_LL_DRIVER
  c include: ..\inc;..\..\Drivers\CMSIS\Include;..\..\Drivers\CMSIS\Device\ST\STM32L1xx\Include;..\..\Drivers\STM32L1xx_HAL_Driver\Inc;..\..\Drivers\BSP\STM32L152C-Discovery
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group CMSIS
    ../../Drivers/CMSIS/Device/ST/STM32L1xx/Source/Templates/: system_stm32l1xx.c
    ../../Drivers/CMSIS/Device/ST/STM32L1xx/Source/Templates/arm/: startup_stm32l152xb.s
  group User
    ../src/: main.c
    ../../: README.md
  group Drivers
    ../../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_ll_utils.c stm32l1xx_ll_gpio.c stm32l1xx_ll_rcc.c stm32l1xx_ll_pwr.c stm32l1xx_ll_adc.c stm32l1xx_ll_lcd.c stm32l1xx_ll_usart.c
    ../../Drivers/BSP/STM32L152C-Discovery/: stm32l152_glass_lcd.c
