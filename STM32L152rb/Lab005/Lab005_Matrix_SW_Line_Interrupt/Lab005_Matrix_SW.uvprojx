# Keil uVision project Lab005_Matrix_SW.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32L152RBTx STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.4.1
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Lab005_Matrix_SW
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: C:\Users\phank\AppData\Local\Arm\Packs\Keil\STM32L1xx_DFP\1.4.1\Drivers\STM32L1xx_HAL_Driver\Inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source Group 1
    ./: main.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.10.3
